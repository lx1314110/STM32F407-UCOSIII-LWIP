# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; BYTE_ORDER=LITTLE_ENDIAN; STM32F40XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; APP; APP\cfg; APP\inc; APP\src; BSP; BSP\inc; BSP\src; BSP\STM32; BSP\STM32\CMSIS; BSP\STM32\CMSIS\Include; BSP\STM32\ETH_Driver; BSP\STM32\ETH_Driver\inc; BSP\STM32\ETH_Driver\src; BSP\STM32\StdPeriph_Driver; BSP\STM32\StdPeriph_Driver\inc; BSP\STM32\StdPeriph_Driver\src; uC-CPU; uC-CPU\CFG; uC-CPU\ARM-Cortex-M3; uC-CPU\ARM-Cortex-M3\IAR; uC-LIB; uC-LIB\CFG; uCOS-III; uCOS-III\CFG; uCOS-III\Ports; uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; uCOS-III\Source; LWIP; LWIP\src; LWIP\src\api; LWIP\src\core; LWIP\src\core\ipv4; LWIP\src\core\ipv6; LWIP\src\core\snmp; LWIP\src\include; LWIP\src\include\ipv4; LWIP\src\include\ipv4\lwip; LWIP\src\include\lwip; LWIP\src\include\netif; LWIP\src\netif; LWIP\port; LWIP\port\STM32; LWIP\port\STM32\arch; LWIP\port\STM32\arch\uCOS-III; LWIP\port\STM32\include; LWIP\port\STM32\include\arch; LWIP\port\STM32\include\netif; LWIP\port\STM32\netif; NETAPP; NETAPP\src; NETAPP\inc; STM322xG_EVAL; STM322xG_EVAL\Common; APP\Web; APP\Config; BSP\STM32\CMSIS\Include; BSP\STM32\CMSIS\Device\ST\STM32F4xx\Include; BSP\STM32\STM32F4x7_ETH_Driver\inc; BSP\STM32\STM32F4xx_StdPeriph_Driver\inc; $TOOLKIT_DIR$\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EPMA14P-3.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: BSP\stm32f407xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: 修改记录.txt
  group APP/config_head
    APP/cfg/: app_cfg.h os_cfg_app.h
    uC-CPU/CFG/: cpu_cfg.h
    uC-LIB/Cfg/: lib_cfg.h
    uCOS-III/Cfg/: os_cfg.h
  group APP/config_head/inc
    APP/inc/: includes.h os_app_hooks.h
    BSP/STM32/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx_conf.h
  group APP/user_app
    APP/src/: app.c app_vect.c os_app_hooks.c
  group APP/user_config
    APP/Config/: config.c
  group APP/user_eeprom
    APP/Eeprom/: eeprom.c
  group APP/user_main
    APP/Control/: control.c control_main.c Extent INT.c
  group APP/user_shell
    APP/Shell/: Shell_main.c
  group APP/user_snmp
    APP/Snmp/: snmp_flash.c snmp_main.c snmp_mib.C snmp_mib.h snmp_SNMP.c snmp_snmpAgent.c snmp_snmpInit.c snmp_snmpRefresh.c
  group APP/user_uart
    APP/Sensor/: serial.c
  group APP/user_web
    APP/Web/: fs.c httpd.c ustdlib.c web_main.c
  group APP/user_web/src
    BSP/src/: bsp.c bsp_eth.c bsp_int.c bsp_lib.c bsp_periph.c
  group bsp
    BSP/: stm32f407xE.icf
  group bsp/inc
    BSP/inc/: bsp.h bsp_eth.h
  group bsp/STM32/CMSIS/inc
    BSP/STM32/CMSIS/Include/: core_cm3.h
    BSP/STM32/CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h
  group bsp/STM32/CMSIS/src
    BSP/STM32/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group bsp/STM32/ETH_Driver/inc
    BSP/STM32/STM32F4x7_ETH_Driver/inc/: stm32f4x7_eth.h stm32f4x7_eth_conf.h
  group bsp/STM32/ETH_Driver/src
    BSP/STM32/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group bsp/STM32/StdPeriph_Driver
    BSP/STM32/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
  group bsp/STM32/StdPeriph_Driver/inc
    BSP/STM32/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group bsp/STM32/StdPeriph_Driver/src
    BSP/STM32/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group lwip/port/STM32/arch
    LWIP/port/STM32/arch/: lwip.c
  group lwip/port/STM32/arch/uCOS-III
    LWIP/port/STM32/arch/uCOS-III/: sys_arch.c
  group lwip/port/STM32/hetif
    LWIP/port/STM32/netif/: ethernetif.c
  group lwip/port/STM32/include
    LWIP/port/STM32/include/: lwip.h lwipopts.h
  group lwip/port/STM32/include/arch
    LWIP/port/STM32/include/arch/: bpstruct.h cc.h cpu.h epstruct.h perf.h sys_arch.h
  group lwip/port/STM32/include/netif
    LWIP/port/STM32/include/netif/: ethernetif.h
  group lwip/src/api
    LWIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    LWIP/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip/src/core/ipv4
    LWIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip/src/core/ipv6
    LWIP/src/core/ipv6/: icmp6.c inet6.c ip6.c ip6_addr.c
  group lwip/src/include/ipv4/lwip
    LWIP/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group lwip/src/include/ipv6/lwip
    LWIP/src/include/ipv6/lwip/: icmp.h inet.h ip.h ip_addr.h
  group lwip/src/include/lwip
    LWIP/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h sockets.h stats.h sys.h tcp.h tcp_impl.h tcpip.h timers.h udp.h
  group lwip/src/include/netif
    LWIP/src/include/netif/: etharp.h loopif.h ppp_oe.h slipif.h
  group lwip/src/netif
    LWIP/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group lwip/uC/CPU/inc
    uC-CPU/ARM-Cortex-M3/IAR/: cpu.h
    uC-CPU/: cpu_core.h cpu_def.h
  group lwip/uC/CPU/src
    uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
    uC-CPU/: cpu_core.c
  group uC/lib/inc
    uC-LIB/: lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uC/lib/src
    uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III/inc
    uCOS-III/Source/: os.h os_type.h
  group uC/OS-III/Ports
    uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/src
    uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
